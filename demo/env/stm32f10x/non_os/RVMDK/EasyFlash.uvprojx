# Keil uVision project EasyFlash.uvprojx, settings and files
target stm32f103xE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EasyFlash
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,USE_FULL_ASSERT
  c include: ..\app\inc;..\components\rtt_uart;..\components\others;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS_RVMDK\CM3\CoreSupport;..\Libraries\CMSIS_RVMDK\CM3\DeviceSupport\ST\STM32F10x;..\components\easyflash\inc;..\..\..\..\..\easyflash\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../APP/src/: app.c stm32f10x_it.c
    ../app/inc/: stm32f10x_conf.h
  group bsp
    ../components/others/: bsp.c
    ../Libraries/CMSIS_RVMDK/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group easyflash
    ../../../../../easyflash/src/: easyflash.c ef_env.c ef_iap.c ef_utils.c
    ../components/easyflash/port/: ef_port.c
  group std_periph_driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group cmsis
    ../Libraries/CMSIS_RVMDK/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
software components: CMSIS:CORE 5.0.1
